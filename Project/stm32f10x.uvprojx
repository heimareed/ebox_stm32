# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox_v1_0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\ebox_v1_0;..\util;..\edriver;..\network;..\fat;..\user;..\other;..\network\MQTTPacket\src;..\network\MQTTPacket\interface
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox
    ../ebox_v1_0/: ebox_v1_0.lib object.cpp
  group util
    ../util/: util.cpp
  group edriver
    ../edriver/: 74HC595.cpp Button.cpp DS3231.cpp encoder.cpp LCD1602.cpp LED.cpp MPU6050.CPP w25x16.cpp w5500.cpp mmc_sd.cpp at24c02.cpp L3G4200D.cpp lsm303dhlc.cpp colorled.cpp Nokia5110.cpp FT800.cpp ws2812.cpp Max7456.cpp NRF24L01.cpp LTC1446.cpp
  group network
    ../network/: socket.cpp dns.cpp udp.cpp tcp.cpp
  group mqtt
    ../network/MQTTPacket/interface/: mqtt_api.cpp transport.cpp
    ../network/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group fat
    ../fat/: wrapperdiskio.cpp diskio.c ff.c
  group other
    ../other/: color_convert.cpp
  group user
    ../user/: main.cpp
